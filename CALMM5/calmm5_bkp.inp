CALMM5 Output from Saudi Arabia Domain (CALMM5/3D-2D format)
/data/zhong/alamos/MM5out/base/mm5ala01_d3.dat.v2 ! MM5 data input file name (no space before or within filename)  
samp.grb          ! CALMM5/M3D output file name (no space before or within filename)
calmm5.lst        ! List file name (no space before or within filename)  
2                 ! Options for selecting a region (1: use lat/long; 2: use J/I)
2                 ! Southernmost latitude (in decimal, positive for NH), or J1/Y1
5                 ! Northermost  latitude (in decimal, positive for NH), or J2/Y2
3                 ! Westernmost  longitude (in decimal, negative for WH), or I1/X1
6                 ! Easternmost  longitude (in decimal, negative for WH), or I2/X2
2000050701        ! Starting date (year-month-day-UTC_hour)(yyyymmddhh)
2000050703        ! Ending date (year-month-day-UTC_hour)(yyyymmddhh)
1                 ! Output format (1,2,3,4,5 - 1 for CALMM5/M3D-M2D format)
Keep this line - The following lines vary depending on the output format selected
1 1 1 1 1         ! Output W, RH, cloud and rain, ice and snow, graupel
1                 ! Flag for 2-D variables output (1/0: output/not)
samp2d.mm5        ! File name for 2-D variable output (needed only 2-D Flag=1)
1                 ! Lowest extraction level in MM5 
14                ! Highest extraction level in MM5 

**********  The lines below are comments. They are not used *********************** 

----- This is the user-control input file for calmm5.f ------

Note:
  A. CALMM5 output format options are (select one only): 
     1. MM5.DAT, 2: MM4.DAT (ASCII), 3: GrADS, 4: VIS5D, 5: NetCDF.
  B. The first line is title line.
  C. Contents after "!" are comments. At least one blank space is needed before it.
  D. Lines above "Keep this line..." are needed for all four available
     formats. 
  E. The lines below "Keep this line..." depend on the selected output format:
     i) For the output option 1 (MM5.DAT), five integers (0/1) in one line are needed,
        which determine to output or not for five variables in MM5. The five 
        variables are:
        1: W (vertical velocity), 2: humidity, 3: cloud and rain, 
        4: ice and snow, 5: graupel.
     ii) For the output option 2 (MM4.DAT), nothing more is needed
     iii) For the output option 3 (GrADS), see the following sample for more input
          lines. Note that the variable names must be the same as those used 
          in MM5 output. Use absolute path for output file name since GrADS 
          doesn't like relative path if the data file is not in the same 
          directory as GrADS. 
     iv) For the output option 4 (VIS5D), see the following sample for more input 
         lines. These lines are very similar to GrADS input lines
     v) For the output option 5 (NetCDF), see the following sample for more input 
         lines. These lines are very similar to GrADS input lines

---- Sample input lines below  "Keep this line" -----

Option 1 - MM5.DAT format:
1 1 1 1 1       ! Output W, RH, cloud and rain, ice and snow, graupel

Option 2 - MM4.DAT format
No more lines needed

Option 3 - GrADS format:
2,3           ! Numbers of 3-D variables and levels in GrADS (see Note 3 below)
1,2,3         ! Output levels of 3-D in GrADS (must equal number of levels)
U             ! 1st 3-D variable (the total must equal number of variables)
V             ! 2nd 3-D variable
2             ! Numbers of 2-D variables in GrADS (see Note 3 below)
PSTARCRS      ! 1st 2-D variable (the total must equal number of variables)
TERRAIN       ! 2nd 2-D variable
0             ! Numbers of 1-D variables

Option 4 - VIS5D format:
2,3           ! Numbers of 3-D variables and levels in GrADS (see Note 3 below)
1,2,3         ! Output levels of 3-D in GrADS (must equal number of levels)
U             ! 1st 3-D variable (the total must equal number of variables)
V             ! 2nd 3-D variable
1             ! Numbers of 2-D variables in GrADS (see Note 3 below)
TERRAIN       ! 2nd 2-D variable
0             ! Numbers of 1-D variables

Option 5 - NetCDF format:
2,3           ! Numbers of 3-D variables and levels in GrADS (see Note 3 below)
1,2,3         ! Output levels of 3-D in GrADS (must equal number of levels)
U             ! 1st 3-D variable (the total must equal number of variables)
V             ! 2nd 3-D variable
1             ! Numbers of 2-D variables in GrADS (see Note 3 below)
PSTARCRS      ! 1st 2-D variable (the total must equal number of variables)
0             ! Numbers of 1-D variables

---------------------------------------------------------------------------
